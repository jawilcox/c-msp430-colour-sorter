# IAR project M&M Project.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group driverlib/MSP430FR2xx_4xx
    driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h pmm.c pmm.h rtc.c rtc.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/deprecated/CCS
    driverlib/MSP430FR2xx_4xx/deprecated/CCS/: msp430fr2xx_4xxgeneric.h
  group driverlib/MSP430FR2xx_4xx/deprecated/IAR
    driverlib/MSP430FR2xx_4xx/deprecated/IAR/: msp430fr2xx_4xxgeneric.h
  group driverlib/MSP430FR2xx_4xx/inc
    driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h hw_regaccess.h version.h
  group lcdDrivers
    lcdDrivers/: hal_LCD.c hal_LCD.h
  group ownDrivers
    ownDrivers/: ADC_Driver.c ADC_Driver.h interface_Driver.c interface_Driver.h LCD_Driver.c LCD_Driver.h motor_Driver.c motor_Driver.h sensor_Driver.c sensor_Driver.h timer_Driver.c timer_Driver.h
